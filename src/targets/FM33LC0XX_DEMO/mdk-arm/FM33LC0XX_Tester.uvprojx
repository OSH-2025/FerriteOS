# Keil uVision project FM33LC0XX_Tester.uvprojx, settings and files
target Example (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LC04X FMSH
  pack: Keil.FM33LC0XX_DFP.1.0.4
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33LC0XX_Tester +hex
  group Application/MDK-ARM
    ../: los_startup_gcc.S
  group Application/MF-config
    ../Src/: mf_config.c
  group Application/User
    ../Src/: main.c sys_init.c tim.c usart.c user_init.c user_task.c
    ../../bsp/common/: demo_entry.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
  group Drivers/FM33LC0xx_LL_Driver
    ../../bsp/drivers/FM33LC0xx_LL_Driver/Src/: fm33lc0xx_ll_adc.c fm33lc0xx_ll_atim.c fm33lc0xx_ll_bstim.c fm33lc0xx_ll_dma.c fm33lc0xx_ll_flash.c fm33lc0xx_ll_gpio.c fm33lc0xx_ll_gptim.c fm33lc0xx_ll_iwdt.c fm33lc0xx_ll_lptim.c fm33lc0xx_ll_rcc.c fm33lc0xx_ll_svd.c fm33lc0xx_ll_uart.c fm33lc0xx_ll_wwdt.c
  group Lib/Libsec
    ../../../lib/libsec/src/: fscanf_s.c fwscanf_s.c gets_s.c memcpy_s.c memmove_s.c memset_s.c scanf_s.c snprintf_s.c sprintf_s.c sscanf_s.c strcat_s.c strcpy_s.c strncat_s.c strncpy_s.c strtok_s.c swprintf_s.c swscanf_s.c vfscanf_s.c vfwscanf_s.c vscanf_s.c vsnprintf_s.c vsprintf_s.c vsscanf_s.c vswprintf_s.c vswscanf_s.c vwscanf_s.c securecutil.c secureinput_a.c secureinput_w.c secureprintoutput_a.c secureprintoutput_w.c wcscat_s.c wcscpy_s.c wcsncat_s.c wcsncpy_s.c wcstok_s.c wmemcpy_s.c wmemmove_s.c wscanf_s.c
  group LiteOS/Arch
    ../../../arch/arm/cortex_m/src/: canary.c cpu.c fault.c fpb.c task.c dispatch.S exception.S jmp.S
  group LiteOS/Kernel
    ../../../kernel/base/: los_bitmap.c los_err.c los_event.c los_exc.c los_hwi.c los_lockdep.c los_misc.c los_mp.c los_mux.c los_percpu.c los_printf.c los_queue.c los_ringbuf.c los_sem.c los_sortlink.c los_stackinfo.c los_swtmr.c los_task.c los_tick.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/memstat/: los_memstat.c
    ../../../kernel/base/sched/sched_sq/: los_priqueue.c los_sched.c
    ../../../kernel/init/: los_init.c
  group LiteOS/Driver
    ../../../drivers/interrupt/: arm_nvic.c
    ../../../drivers/uart/src/arm_generic/: uart_debug.c
    ../../../drivers/timer/: cortex_m_systick.c
